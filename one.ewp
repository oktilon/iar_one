# IAR project one.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F40_41xxx; HSE_VALUE=8000000; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: Libraries\CMSIS\Include; Libraries\CMSIS\Device\ST\STM32F4xx\Include; Libraries\STM32F4xx_StdPeriph_Driver\inc; Libraries\CMSIS\Device\ST\STM32F4xx\Source\Templates; Libraries\CMSIS\Device\ST\STM32F4xx\Source\Templates\iar; Libraries\STM32F4xx_StdPeriph_Driver\src; Application\inc; Application\src; Application
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: one.hex
  ILINK.IlinkOutputFile: one.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    Application/: main.c project_config.h stm32f4xx_conf.h
    Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f40_41xxx.s
    Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Application/inc
    Application/inc/: board.h task.h
  group Application/src
    Application/src/: board.c task.c
  group library
    Libraries/CMSIS/Device/ST/STM32F4xx/Include/: stm32f4xx.h
  group library/inc
    Libraries/STM32F4xx_StdPeriph_Driver/inc/: misc.h stm32f4xx_adc.h stm32f4xx_dma.h stm32f4xx_gpio.h stm32f4xx_rcc.h stm32f4xx_syscfg.h
  group library/src
    Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c
